# Keil uVision project ProjetVide.uvprojx, settings and files
target Reel (6220000::V6.22::ARMCLANG)
  device: STM32F100C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Projet3FISA
  c flags: Optim=1 OneElfS=1 v6LangP=3 wLevel=2
  c include: ..\Driver\Include;..\Driver\Source;..\ProjetVide
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application
    ./Application/: principal.c
    ../Driver/Source/: Girouette.c MyTimer.c Voile.c
    ./: Plateau.c UART.c Batterie.c
  group Driver
    ../Driver/Include/: Girouette.h MyTimer.h Voile.h
    ./: Plateau.h UART.h Batterie.h
target Simulation (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ProjetVide
  c flags: Optim=1 OneElfS=1 v6LangP=3 wLevel=2
  c include: ..\Driver\Include;..\Driver\Source;..\ProjetVide
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
